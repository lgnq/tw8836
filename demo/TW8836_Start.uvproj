# Keil uVision project TW8836_Start.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C390 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(40000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: TW8836_Start +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: EVB_10 nullFn="//"
  link misc: RECURSIONS (30)
  group Source Group 1
    source36Start/: CPU.c Util.c Printf.c Release.txt L51_BANK.A51
    ./Source36Start/: main.c SPI.c i2c.c OutputCtrl.c Settings.c monitor.c Monitor_MCU.c monitor_SPI.c
