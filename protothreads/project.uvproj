# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C390 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(40000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: project +hex
  c flags: Optimize=7 SizeSpeed=1
  group os
    ./os/: OS_CORE.C OS_Q.C OS_SEM.C
  group user
    ./: main.c cpu.c uart.c
  group Target CPU
    ./keilc51/: OS_CPU_C.C OS_CPU_A.ASM
